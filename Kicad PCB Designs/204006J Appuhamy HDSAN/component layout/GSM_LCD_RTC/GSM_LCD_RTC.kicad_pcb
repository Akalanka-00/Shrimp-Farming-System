# Repository Akalanka-00/Shrimp-Farming-System

File README.md:

# finalize-Project
 Srimp Farming System [Level 01 Group Project]

## KiCad design Kicad PCB Designs/204006J Appuhamy HDSAN/component layout/GSM_LCD_RTC/GSM_LCD_RTC.kicad_pcb

Parts:
J1: Power IN; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
J2: LCD Connector; PinHeader_1x16_P2.54mm_Vertical
J3: GSM Connecetor; PinSocket_1x03_P2.54mm_Vertical
R1, R2, R3, R4: R; R_Axial_DIN0411_L9.9mm_D3.6mm_P20.32mm_Horizontal
RV1: 10K Potentiometer; Potentiometer_ACP_CA6-H2,5_Horizontal
U1: ATmega32A-P; DIP-40_W15.24mm
U2: PCF8574; Pololu_Breakout-16_15.2x20.3mm
U3: DS3232M; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
unnamed: J1.1, J2.2, J2.15, R1.2, R2.2, R3.2, R4.2, RV1.1, U1.10 (VCC), U2.1 (A0), U2.2 (A1), U2.3 (A2), U2.16 (VDD), U3.2 (VCC)
unnamed: J1.2, J2.1, J2.7, J2.8, J2.9, J2.10, J2.16, J3.3, RV1.3, U1.11 (GND), U1.31 (GND), U3.5 (GND)
unnamed: J2.3, RV1.2
unnamed: J2.4, U2.4 (P0)
unnamed: J2.5, U2.5 (P1)
unnamed: J2.6, U2.6 (P2)
unnamed: J2.11, U2.9 (P4)
unnamed: J2.12, U2.10 (P5)
unnamed: J2.13, U2.11 (P6)
unnamed: J2.14, U2.12 (P7)
unnamed: J3.1, U1.14 (PD0)
unnamed: J3.2, U1.15 (PD1)
unnamed: R1.1, R3.1, U1.22 (PC0), U2.14 (SCL), U3.8 (SCL)
unnamed: R2.1, R4.1, U1.23 (PC1), U2.15 (SDA), U3.7 (SDA)

Board: 2 copper layers, 11 parts (0 on the bottom side), 14 nets.

## KiCad design Kicad PCB Designs/Weight+Load Cell+Gear+Motor Driver/Text 4.kicad_pcb

Parts:
Atmega32: ATmega32A-P; DIP-40_W15.24mm
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2: 10 μF; C_0201_0603Metric
C3, C4: 0.1 μF; C_0201_0603Metric
HX711: HX711
J2: Screw_Terminal_01x02
J4: Screw_Terminal_01x04
L293D1: L293D; DIP-16_W7.62mm
Q1: 2N4403; TO-92_Inline
R1: 20 kΩ; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Vertical
R2: 8.2 kΩ; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Vertical
R3, R4: 100 Ω; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Vertical
ST1: Screw_Terminal_01x03; TerminalBlock_Dinkle_DT-55-B01X-03_P10.00mm

Connections:
unnamed: Atmega32.27 (PC5), BZ1.1 (-)
unnamed: Atmega32.11 (GND), Atmega32.31 (GND), BZ1.2 (+), C1.2, C2.2, C3.1, HX711.5 (AGND), HX711.9 (INB-), HX711.10 (INB+), HX711.14 (XI), HX711.15 (RATE), J4.2, L293D1.4 (GND), R2.2, ST1.1
unnamed: Atmega32.10 (VCC), C1.1, HX711.1 (VSUP), HX711.16 (DVDD), L293D1.1 (EN1,2), L293D1.16 (VCC1), Q1.1 (E), ST1.3
unnamed: C2.1, HX711.3 (AVDD), J4.1
unnamed: C3.2, HX711.6 (VGB)
unnamed: C4.1, J4.3, R3.2
unnamed: C4.2, J4.4, R4.2
unnamed: HX711.2 (BASE), Q1.2 (B)
unnamed: HX711.4 (VFB), R1.2, R2.1
unnamed: HX711.7 (IN-), R3.1
unnamed: HX711.8 (IN+), R4.1
unnamed: Atmega32.17 (PD3), HX711.11 (PD_SCK)
unnamed: Atmega32.16 (PD2), HX711.12 (DOUT)
unnamed: Atmega32.24 (PC2), L293D1.2 (1A)
unnamed: J2.1, L293D1.3 (1Y)
unnamed: J2.2, L293D1.6 (2Y)
unnamed: Atmega32.25 (PC3), L293D1.7 (2A)
unnamed: L293D1.8 (VCC2), ST1.2
unnamed: Q1.3 (C), R1.1

Notes on the sheet:
Gear Motor
Load cell
12V
Weight Sensor
GND

Board: 2 copper layers, 83.2 x 62.9 mm, 22 parts (0 on the bottom side), 19 nets.

Other parts of the board:
MH1, MH2, MH3, MH4, MH5, MH6: MountingHole_2.2mm_M2_Pad

## Commit log

2022-05-14 phone
2022-05-22 animation
2022-05-22 Indivitual Contribution
2022-05-22 Indivitual_Contributions
2022-05-22 documents
2022-05-22 sara
2022-05-22 path
2022-05-22 refresh
2022-06-05 kicad
